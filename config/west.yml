## config/west.yml
```yaml
manifest:
  projects:
    - name: zmk-config
      url: https://github.com/waylonwalker/zmk-config.git
      revision: main
      path: config
```
